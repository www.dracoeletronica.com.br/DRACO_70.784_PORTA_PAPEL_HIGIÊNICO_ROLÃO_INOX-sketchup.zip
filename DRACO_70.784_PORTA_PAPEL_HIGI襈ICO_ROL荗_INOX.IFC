Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.784_PORTA_PAPEL_HIGIÊNICO_ROLÃO_INOX.IFC
Time: 2023-05-16T11:51:45
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 70.278_TRAVA_DA_TAMPA_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_XXX.XXX_CORPO_PORTA_PAPEL_HIGIÊNICO_ROLÃO_INOX_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_XXX.XXX_FUNDO_PORTA_PAPEL_HIGIÊNICO_ROLÃO_INOX_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: PINO_ARTICULAÇÃO_Default (2)
In: Default Storey
Material: AISI 1020
